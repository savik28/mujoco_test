Commit message: marker visualisation

File: urdf/ur5_with_gripper.urdf (robot description, URDF)
Before this commit: robot ur5, 25 links, 24 joints
Joints:
- joint world_joint: origin xyz=0.0 0.0 0.01 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.0 rpy=0.0 0.0 3.14
